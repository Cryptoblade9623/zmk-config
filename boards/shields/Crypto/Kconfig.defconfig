## boards/shields/Crypto/Kconfig.defconfig
```kconfig
if SHIELD_CRYPTO_LEFT || SHIELD_CRYPTO_RIGHT

config ZMK_KEYBOARD_NAME
	default "Crypto"

endif
```
